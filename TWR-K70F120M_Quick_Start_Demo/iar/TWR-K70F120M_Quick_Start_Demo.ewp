# IAR project TWR-K70F120M_Quick_Start_Demo.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: K70Xxxx Freescale K70Xxxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\lib\twrk70f120m.iar\bsp; ..\..\..\lib\twrk70f120m.iar\psp; ..\..\..\lib\twrk70f120m.iar\bsp\Generated_Code; ..\..\..\lib\twrk70f120m.iar; ..\..\..\lib\twrk70f120m.iar\rtcs; ..\..\..\lib\twrk70f120m.iar\mfs; ..\..\..\lib\twrk70f120m.iar\usb\host; ..\..\..\lib\twrk70f120m.iar\usb\device; ..\..\..\lib\twrk70f120m.iar\shell; ..; ..\tsi; ..\adc; ..\usb; ..\web
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\lib\twrk70f120m.iar\bsp; ..\..\..\lib\twrk70f120m.iar\psp; ..\..\..\lib\twrk70f120m.iar\bsp\Generated_Code; ..\..\..\lib\twrk70f120m.iar; ..\..\..\lib\twrk70f120m.iar\rtcs; ..\..\..\lib\twrk70f120m.iar\mfs; ..\..\..\lib\twrk70f120m.iar\usb\host; ..\..\..\lib\twrk70f120m.iar\usb\device; ..\..\..\lib\twrk70f120m.iar\shell; ..
  OBJCOPY.OOCOutputFile: TWR-K70F120M_Quick_Start_Demo.srec
  ILINK.IlinkOutputFile: TWR-K70F120M_Quick_Start_Demo.out
  ILINK.IlinkIcfFile: ..\..\..\lib\twrk70f120m.iar\bsp\intflash_sramdata.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: TWR-K60N512_Quick_Start_Demo.out
  group MFS Libraries
    ../../../lib/twrk70f120m.iar/mfs/: mfs_twrk70f120m.a mfs_twrk70f120m_d.a
  group MQX Libraries
    ../../../lib/twrk70f120m.iar/bsp/: bsp_twrk70f120m.a bsp_twrk70f120m_d.a
    ../../../lib/twrk70f120m.iar/psp/: psp_twrk70f120m.a psp_twrk70f120m_d.a
  group RTCS Libraries
    ../../../lib/twrk70f120m.iar/rtcs/: rtcs_twrk70f120m.a rtcs_twrk70f120m_d.a
  group Shell Libraries
    ../../../lib/twrk70f120m.iar/shell/: shell_twrk70f120m.a shell_twrk70f120m_d.a
  group Source
    ../: Accel_Task.c demo.h Demo_Task.c DemoIO.c DemoIO.h Game_Task.c Init_Task.c SDCard_Task.c Shell_Commands.c Shell_Commands.h Tasks.c
  group Source/adc
    ../adc/: adc16.c adc16.h ADC_Task.c
  group Source/tsi
    ../tsi/: tsi.c tsi.h
  group Source/usb
    ../usb/: mouse.c mouse.h usb_descriptor.c usb_descriptor.h
  group Source/web
    ../web/: cgi.h cgi_index.c html.h html_util.c RTCS.c tfs_data.c web.h
  group USB Device Libraries
    ../../../lib/twrk70f120m.iar/usb/device/: usb_ddk_twrk70f120m.a usb_ddk_twrk70f120m_d.a
  group USB Host Libraries
    ../../../lib/twrk70f120m.iar/usb/host/: usb_hdk_twrk70f120m.a usb_hdk_twrk70f120m_d.a
