<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TWR-K70F120M_Quick_Start_Demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


