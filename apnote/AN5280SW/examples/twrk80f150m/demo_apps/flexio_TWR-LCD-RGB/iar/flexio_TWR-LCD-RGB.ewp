# IAR project flexio_TWR-LCD-RGB.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 Freescale MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK80FN256VDC15; TWR_K80F150M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../platform/osa/inc; ../../../../../platform/utilities/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/devices; ../../../../../platform/devices/MK80F25615/include; ../../../../../platform/devices/MK80F25615/startup; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../..; ..; ../images; ../flexio_lcd; ../lcds
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: flexio_TWR-LCD-RGB.srec
  ILINK.IlinkOutputFile: flexio_TWR-LCD-RGB.out
  ILINK.IlinkConfigDefines: __stack_size__=0x2000; __heap_size__=0x2000
  ILINK.IlinkIcfFile: MK80FN256xxx15_flash_sdram.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K80F25615/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK80FN256VDC15; TWR_K80F150M; TOWER
  ICCARM.CCIncludePath2: ../../../../../platform/osa/inc; ../../../../../platform/utilities/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/devices; ../../../../../platform/devices/MK80F25615/include; ../../../../../platform/devices/MK80F25615/startup; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../..
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: ../../../../../platform/devices/MK80F25615/linker/iar/MK80FN256xxx15_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/ksdk_platform_lib/iar/K80F25615/release/libksdk_platform.a
  group board
    ../../../: board.c board.h gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h
    ../: flexio_lcd_pins.c flexio_lcd_pins.h hardware_init.c
  group images
    ../images/: image_files.h image_pragmas.h NXP_Logo.c Solutions.c
  group source
    ../: flexio_lcd.c flexio_lcd.h flexio_lcd_irq.c fsl_gpio_irq.c main.c qspi.c qspi.h
  group source/flexio_lcd
    ../flexio_lcd/: flexio_lcd_edma_driver.c flexio_lcd_edma_driver.h flexio_lcd_hal.c flexio_lcd_hal.h
  group source/fsl_sdram_driver
    ../: fsl_sdram_driver.c fsl_sdram_driver.h
  group source/LCDs
    ../lcds/: lcd.h TWR-LCD-RGB.h
  group startup
    ../../../../../platform/devices/: startup.c startup.h
    ../../../../../platform/devices/MK80F25615/startup/iar/: startup_MK80F25615.s
    ../../../../../platform/devices/MK80F25615/startup/: system_MK80F25615.c system_MK80F25615.h
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
