# IAR project app_demo_k80_flexio_camera.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK80FN256xxx15 Freescale MK80FN256xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK80FN256VDC15; TWR_K80F150M; TOWER
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\src\ov7670\; ..\src\ssd1289\; ..\src\flexbus\; ..\..\../platform/osa/inc; ..\..\../platform/utilities/inc; ..\..\../platform/CMSIS/Include; ..\..\../platform/devices; ..\..\../platform/devices/MK80F25615/include; ..\..\../platform/devices/MK80F25615/startup; ..\..\../platform/hal/inc; ..\..\../platform/drivers/inc; ..\..\../platform/system/inc; ../../..; ../board; ..\..\../platform/drivers/src/adc16; ..\..\../platform/drivers/src/cmp; ..\..\../platform/drivers/src/cmt; ..\..\../platform/drivers/src/crc; ..\..\../platform/drivers/src/dac; ..\..\../platform/drivers/src/dspi; ..\..\../platform/drivers/src/edma; ..\..\../platform/drivers/src/ewm; ..\..\../platform/drivers/src/flexbus; ..\..\../platform/drivers/src/flexio; ..\..\../platform/drivers/src/ftm; ..\..\../platform/drivers/src/gpio; ..\..\../platform/drivers/src/i2c; ..\..\../platform/drivers/src/lmem; ..\..\../platform/drivers/src/lptmr; ..\..\../platform/drivers/src/lpuart; ..\..\../platform/drivers/src/mpu; ..\..\../platform/drivers/src/pdb; ..\..\../platform/drivers/src/pit; ..\..\../platform/drivers/src/qspi; ..\..\../platform/drivers/src/sdramc; ..\..\../platform/drivers/src/trng; ..\..\../platform/drivers/src/rtc; ..\..\../platform/drivers/src/sai; ..\..\../platform/drivers/src/sdhc; ..\..\../platform/drivers/src/tpm; ..\..\../platform/drivers/src/tsi; ..\..\../platform/drivers/src/vref; ..\..\../platform/drivers/src/wdog; ..\..\../platform/drivers/src/smartcard; ..\..\../platform/drivers/src/smartcard/interface
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: app_demo_k80_flexio_camera.out
  ILINK.IlinkIcfFile: ..\..\../platform/devices/MK80F25615/linker/iar/MK80FN256xxx15_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\../lib/ksdk_platform_lib/iar/K80F25615/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK80FN256VDC15; TWR_K80F150M; TOWER
  ICCARM.CCIncludePath2: ..\..\../platform/osa/inc; ..\..\../platform/utilities/inc; ..\..\../platform/CMSIS/Include; ..\..\../platform/devices; ..\..\../platform/devices/MK80F25615/include; ..\..\../platform/devices/MK80F25615/startup; ..\..\../platform/hal/inc; ..\..\../platform/drivers/inc; ..\..\../platform/system/inc; ../../..; ../board; ..\..\../platform/drivers/src/adc16; ..\..\../platform/drivers/src/cmp; ..\..\../platform/drivers/src/cmt; ..\..\../platform/drivers/src/crc; ..\..\../platform/drivers/src/dac; ..\..\../platform/drivers/src/dspi; ..\..\../platform/drivers/src/edma; ..\..\../platform/drivers/src/ewm; ..\..\../platform/drivers/src/flexbus; ..\..\../platform/drivers/src/flexio; ..\..\../platform/drivers/src/ftm; ..\..\../platform/drivers/src/gpio; ..\..\../platform/drivers/src/i2c; ..\..\../platform/drivers/src/lmem; ..\..\../platform/drivers/src/lptmr; ..\..\../platform/drivers/src/lpuart; ..\..\../platform/drivers/src/mpu; ..\..\../platform/drivers/src/pdb; ..\..\../platform/drivers/src/pit; ..\..\../platform/drivers/src/qspi; ..\..\../platform/drivers/src/sdramc; ..\..\../platform/drivers/src/trng; ..\..\../platform/drivers/src/rtc; ..\..\../platform/drivers/src/sai; ..\..\../platform/drivers/src/sdhc; ..\..\../platform/drivers/src/tpm; ..\..\../platform/drivers/src/tsi; ..\..\../platform/drivers/src/vref; ..\..\../platform/drivers/src/wdog; ..\..\../platform/drivers/src/smartcard; ..\..\../platform/drivers/src/smartcard/interface
  ICCARM.CCOptLevel: 3
  group board
    ../board/: board.c board.h gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h
    ../: hardware_init.c
  group sources
    ../: main.c main.h main_irq.c
  group sources/ov7670
    ../src/ov7670/: fsl_ov7670_driver.c fsl_ov7670_driver.h fsl_sccb_master_driver.c fsl_sccb_master_driver.h ov7670_def.h
  group sources/ssd1289
    ../src/ssd1289/: ssd1289.c ssd1289.h
  group startup
    ../../../platform/devices/: startup.c startup.h
    ../../../platform/devices/MK80F25615/startup/iar/: startup_MK80F25615.s
    ../../../platform/devices/MK80F25615/startup/: system_MK80F25615.c system_MK80F25615.h
  group utilities
    ../../../platform/utilities/src/: fsl_debug_console.c print_scan.c
    ../../../platform/utilities/inc/: fsl_debug_console.h print_scan.h
