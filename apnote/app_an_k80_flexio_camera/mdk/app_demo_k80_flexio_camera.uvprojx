# Keil uVision project app_demo_k80_flexio_camera.uvprojx, settings and files
target app_demo_k80_flexio_camera Debug (ARM-ADS)
  device: MK80FN256xxx15 Freescale
  output: app_demo_k80_flexio_camera.out
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MK80FN256VDC15, TWR_K80F150M, TOWER
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  --library_interface=armcc
  c include: ../../..; ../../../platform/osa/inc; ../../../platform/utilities/inc; ../../../platform/CMSIS/Include; ../../../platform/devices; ../../../platform/devices/MK80F25615/include; ../../../platform/devices/MK80F25615/startup; ../../../platform/hal/inc; ../../../platform/drivers/inc; ../../../platform/system/inc; ../../; ../board; ../../../platform/drivers/src/adc16; ../../../platform/drivers/src/cmp; ../../../platform/drivers/src/cmt; ../../../platform/drivers/src/crc; ../../../platform/drivers/src/dac; ../../../platform/drivers/src/dspi; ../../../platform/drivers/src/edma; ../../../platform/drivers/src/ewm; ../../../platform/drivers/src/flexbus; ../../../platform/drivers/src/flexio; ../../../platform/drivers/src/ftm; ../../../platform/drivers/src/gpio; ../../../platform/drivers/src/i2c; ../../../platform/drivers/src/lmem; ../../../platform/drivers/src/lptmr; ../../../platform/drivers/src/lpuart; ../../../platform/drivers/src/mpu; ../../../platform/drivers/src/pdb; ../../../platform/drivers/src/pit; ../../../platform/drivers/src/qspi; ../../../platform/drivers/src/sdramc; ../../../platform/drivers/src/trng; ../../../platform/drivers/src/rtc; ../../../platform/drivers/src/sai; ../../../platform/drivers/src/sdhc; ../../../platform/drivers/src/tpm; ../../../platform/drivers/src/tsi; ../../../platform/drivers/src/vref; ../../../platform/drivers/src/wdog; ../../../platform/drivers/src/smartcard; ../../../platform/drivers/src/smartcard/interface
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../platform/devices/MK80F25615/linker/arm/MK80FN256xxx15_flash.scf
  link misc: ../../../lib/ksdk_platform_lib/mdk/K80F25615/debug/libksdk_platform.lib
  group startup
    ../../../platform/devices/MK80F25615/startup/arm/: startup_MK80F25615.s
    ../../../platform/devices/MK80F25615/startup/: system_MK80F25615.c system_MK80F25615.h
    ../../../platform/devices/: startup.c startup.h
  group sources
    ../: main.c main.h
  group board
    ../board/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
  group utilities
    ../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../platform/utilities/inc/: fsl_debug_console.h
target app_demo_k80_flexio_camera Release (ARM-ADS)
  device: MK80FN256xxx15 Freescale
  output: app_demo_k80_flexio_camera.out
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG, CPU_MK80FN256VDC15, TWR_K80F150M, TOWER
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: as above
