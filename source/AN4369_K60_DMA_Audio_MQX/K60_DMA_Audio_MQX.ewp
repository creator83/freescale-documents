# IAR project K60_DMA_Audio_MQX.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186
  ICCARM.CCIncludePath2: $_MQX_PATH_$\lib\twrk60n512.iar\bsp\Generated_Code; $_MQX_PATH_$\lib\twrk60n512.iar\bsp; $_MQX_PATH_$\lib\twrk60n512.iar\psp; $_MQX_PATH_$\lib\twrk60n512.iar\psp\dbg; $_MQX_PATH_$\lib\twrk60n512.iar\mfs; $_MQX_PATH_$\mqx\source\psp\cortex; $_MQX_PATH_$\mqx\source\include; $_MQX_PATH_$\lib\twrk60n512.iar; Audio_Card\; Source\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\lib\twrk60n512.iar\bsp; ..\..\..\..\lib\twrk60n512.iar\psp; ..\..\..\..\lib\twrk60n512.iar\bsp\Generated_Code; ..\..\..\..\lib\twrk60n512.iar
  OBJCOPY.OOCOutputFile: K60_DMA_Audio_MQX.srec
  ILINK.IlinkOutputFile: K60_DMA_Audio_MQX.out
  ILINK.IlinkIcfFile: $_MQX_PATH_$\lib\twrk60n512.iar\bsp\intflash.icf
  ILINK.IlinkAdditionalLibs: $_MQX_PATH_$\lib\twrk60n512.iar\bsp\bsp_twrk60n512_d.a; $_MQX_PATH_$\lib\twrk60n512.iar\psp\psp_twrk60n512_d.a; $_MQX_PATH_$\lib\twrk60n512.iar\mfs\mfs_twrk60n512_d.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Audio_Card
    Audio_Card/: AudioCard.c AudioCard.h i2s.c i2s.h sgtl5000.c sgtl5000.h
  group Source
    Source/: audio_dma.c audio_dma.h main_task.c wav_record.h
