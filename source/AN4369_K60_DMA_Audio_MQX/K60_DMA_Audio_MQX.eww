<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\K60_DMA_Audio_MQX.ewp</path>
  </project>
  <batchBuild/>
</workspace>


