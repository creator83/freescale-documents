<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Ex3_12BitDAC_CMP.ewp</path>
  </project>
  <batchBuild/>
</workspace>


